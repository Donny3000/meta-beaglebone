require recipes-core/tinyxml2/libtinyxml.inc

MAJ_VER = "2"
MIN_VER = "6"
BLD_VER = "2"
